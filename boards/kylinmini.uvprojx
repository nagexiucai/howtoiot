# Keil uVision project kylinmini.uvprojx, settings and files
target http (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kylinmini-http +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\library;.\library\bsp\stm32f10xcore;.\library\bsp\stm32f10xfwlib\inc;.\library\http
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./library/bsp/stm32f10xcore/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./library/bsp/stm32f10xcore/startup/arm/: startup_stm32f10x_hd.s
  group firmware
    ./library/bsp/stm32f10xfwlib/src/: misc.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group device
    ./library/esp8266/: esp8266.c
    ./library/m6311/: m6311.c
  group app
    ./v2_3_kylin_open_iot_10086_cn/: main.c
    ./library/edp/: cjson.c edpkit.c
target edp (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: kylinmini-edp +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\library;.\library\bsp\stm32f10xcore;.\library\bsp\stm32f10xfwlib\inc;.\library\edp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
