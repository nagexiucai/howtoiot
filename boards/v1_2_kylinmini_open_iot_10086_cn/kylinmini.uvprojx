# Keil uVision project kylinmini.uvprojx, settings and files
target humiture-monitor (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kylinmini +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c
  group ::CMSIS
    D:/KeilV5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    D:/KeilV5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F103CB/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
  group ::Drivers
    D:/KeilV5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: I2C_STM32F10x.c UART_STM32F10x.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Drivers:I2C 1.01.0, Drivers:UART 1.01.0
